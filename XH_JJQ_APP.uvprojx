# Keil uVision project XH_JJQ_APP.uvprojx, settings and files
target APP (6120000::V6.12::.\ARMCLANG)
  device: GD32F305RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LG_JJQ_APP +hex
  AfterMake: fromelf --bin ".\out_hex\@L.axf" --output ".\out_bin\@L.bin"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F30X_CL,USE_USB_FS,SYS_USING_HEAP,SYS_SUPPORT_OS
  c include: .\GD32F30x_Firmware_Library_V3.0.2\GD32F30x_Firmware_Library_V3.0.2\Firmware\GD32F30x_standard_peripheral\Include;.\GD32F30x_Firmware_Library_V3.0.2\GD32F30x_Firmware_Library_V3.0.2\Firmware\GD32F30x_usbfs_library\driver\Include;.\GD32F30x_Firmware_Library_V3.0.2\GD32F30x_Firmware_Library_V3.0.2\Firmware\GD32F30x_usbfs_library\device\core\Include;.\GD32F30x_Firmware_Library_V3.0.2\GD32F30x_Firmware_Library_V3.0.2\Firmware\GD32F30x_usbfs_library\device\class\cdc\Include;.\GD32F30x_Firmware_Library_V3.0.2\GD32F30x_Firmware_Library_V3.0.2\Firmware\GD32F30x_usbfs_library\ustd\common;.\GD32F30x_Firmware_Library_V3.0.2\GD32F30x_Firmware_Library_V3.0.2\Firmware\GD32F30x_usbfs_library\ustd\class\cdc;.\GD32F30x_Firmware_Library_V3.0.2\GD32F30x_Firmware_Library_V3.0.2\Firmware\GD32F30x_usbfs_library\driver\Include;.\Components\os_port;.\RTOS\FreeRTOS\include;.\RTOS\FreeRTOS\portable\GCC\ARM_CM4F;.\RTOS\FreeRTOS;.\Components\log;.\Components\device;.\Components\utils;.\Components\gps;.\Components\usb;.\Components\led;.\Components\driver;.\Components\menu;.\Components\RFID;.\Components\key;..\app-freeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group main
    ./: main.c
  group CMSIS
    ./GD32F30x_Firmware_Library_V3.0.2/GD32F30x_Firmware_Library_V3.0.2/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ./: gd32f30x_it.c systick.c gd32f30x_hw.c
  group Startup
    ./GD32F30x_Firmware_Library_V3.0.2/GD32F30x_Firmware_Library_V3.0.2/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s startup_gd32f30x_cl.s
  group Peripherals
    ./GD32F30x_Firmware_Library_V3.0.2/GD32F30x_Firmware_Library_V3.0.2/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Usb_Drivers
    ./GD32F30x_Firmware_Library_V3.0.2/GD32F30x_Firmware_Library_V3.0.2/Firmware/GD32F30x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ./GD32F30x_Firmware_Library_V3.0.2/GD32F30x_Firmware_Library_V3.0.2/Firmware/GD32F30x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ./GD32F30x_Firmware_Library_V3.0.2/GD32F30x_Firmware_Library_V3.0.2/Firmware/GD32F30x_usbfs_library/device/class/cdc/Source/: cdc_acm_core.c
  group freeRTOS/Core
    ./RTOS/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freeRTOS/Port
    ./RTOS/FreeRTOS/portable/MemMang/: heap_4.c
    ./RTOS/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
  group Components/driver
    ./Components/driver/: gpio_driver.c lcd_st756x_driver.c w25qxx_driver.c i2c_driver.c
  group Components/device
    ./Components/device/: device.c uart_device.c uart_device.h usb_device.c spi_device.c i2c_device.c
  group Components/log
    ./Components/log/: user_log.c
  group Components/gps
    ./Components/gps/: gps.c
  group Components/menu
    ./Components/menu/: menu.c menu.h lcd_draw.c
  group Components/RFID
    ./Components/RFID/: rfid.c rfid_si522_driver.c
  group Components/usb
    ./Components/usb/: usb_app.c
  group Components/os_port
    ./Components/os_port/: os_port.c
  group Components/utils
    ./Components/utils/: my_queue.c my_linklist.c
  group Components/led
    ./Components/led/: led.c
  group Components/key
    ./Components/key/: key.c
software components: CMSIS:CORE 5.2.0
