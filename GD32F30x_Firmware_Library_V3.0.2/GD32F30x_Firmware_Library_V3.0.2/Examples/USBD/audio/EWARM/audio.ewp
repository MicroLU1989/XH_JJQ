# IAR project audio.ewp, settings and files
configuration USBD (ARM, debug)
  General.OGChipSelectEditMenu: GD32F303xE GD GD32F303xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F30X_HD; USE_USB_AD_SPEAKER
  ICCARM.CCIncludePath2: ..\..\..\..\Firmware\CMSIS\GD\GD32F30x\Include; ..\..\..\..\Firmware\GD32F30x_standard_peripheral\Include; ..\inc; ..\..\..\..\Utilities; ..\..\..\..\Firmware\GD32F30x_usbd_library\class\device\audio\Include; ..\..\..\..\Firmware\GD32F30x_usbd_library\device\Include; ..\..\..\..\Firmware\GD32F30x_usbd_library\usbd\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: audio.srec
  ILINK.IlinkOutputFile: audio.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Appliction
    ../src/: gd32f30x_it.c gd32f30x_usbd_hw.c main.c
  group CMSIS
    ../src/: system_gd32f30x.c
  group Doc
    ../: readme.txt
  group GD32F30x_EVAL
    ../src/: gd32f303c_audio_codec.c
    ../../../../Utilities/: gd32f303e_eval.c
  group GD32F30x_Peripherals
    ../../../../Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_dma.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c
  group Startup
    ../../../../Firmware/CMSIS/GD/GD32F30x/Source/IAR/: startup_gd32f30x_hd.s
  group USBD_Class
    ../../../../Firmware/GD32F30x_usbd_library/class/device/audio/Source/: audio_core.c audio_out_itf.c
  group USBD_Device
    ../../../../Firmware/GD32F30x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Drivers
    ../../../../Firmware/GD32F30x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
